<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LQ_K60_DMA_UART4_OV7620.ewp</path>
  </project>
  <batchBuild/>
</workspace>


